# Keil uVision project test1120.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODAT2
  output: test1120
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 flashLED.c
